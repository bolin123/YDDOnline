# Keil uVision project YDDOnline.uvprojx, settings and files
target YDDOnline (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: YDDOnline_slave +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\src\App;..\..\src\App\Device\Online;..\..\src\App\Sensor;..\..\src\Hal;..\..\src\Sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Hal
    ../../src/Hal/: HalADC.c HalCommon.c HalDAC.c HalExti.c HalFlash.c HalGPIO.c HalRTC.c HalSPI.c HalTimer.c HalUart.c HalWait.c HalPWM.c
  group App
    ../../src/App/: main.c Sensors.c W25Q64.c
    ../../src/App/Sensor/: SGeomagnetism.c SNoise.c SPress.c
    ../../src/App/Device/Online/: YDDOnline.c DigitalLED.c RFModule.c PowerManager.c Temperature.c Wireless.c IR.c DispLoop.c Menu.c WiredProto.c
  group Sys
    ../../src/Sys/: Sys.c SysTimer.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
